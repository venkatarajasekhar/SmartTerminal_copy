# Keil uVision project 智能终端.uvproj, settings and files
target 智能终端 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 智能终端
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,HAVE_CONFIG_H
  c include: .\STM32Libraries\CMSIS\CM3\CoreSupport;.\STM32Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\STM32Libraries\STM32F10x_StdPeriph_Driver\inc;.\RTT\components\finsh;.\RTT\components\dfs\include;.\RTT\include;.\RTT\libcpu\arm\common;.\MySouce;.\MySouce\ATcmd;.\MySouce\cpuUsage;.\MySouce\DS1302;.\MySouce\GNSS;.\MySouce\Keyboard;.\MySouce\LED;.\MySouce\PCP;.\MySouce\RFID;.\MySouce\UartExpand;.\MySouce\Watchdog;.\MySouce\Vocoder;.\MySouce\Vocoder\STM32F10x_Speex_Lib\include;.\MySouce\Vocoder\STM32F10x_Speex_Lib\libspeex;.\MySouce\Vocoder\STM32F10x_Speex_Lib\STM32;.\MySouce\Vocoder\STM32F10x_Speex_Lib\include\speex;.\MySouce\Vocoder\STM32F10x_Speex_Lib\STM32\include;.\MySouce\Vocoder\STM32F10x_Speex_Lib\STM32\libspeex;.\MySouce\Vocoder\STM32F10x_Speex_Lib\STM32\include\speex;.\MySouce\Vocoder\STM32F10x_Speex_Lib\STM32\libspeex\arm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./MySouce/: serial.c application.c startup.c board.c stm32f10x_it.c usart.c MyApplication.c rtc.c
  group Kernel
    ./RTT/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c slab.c thread.c timer.c
  group STM32
    ./RTT/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./RTT/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group finsh
    ./RTT/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group MDK-ARM
    ./STM32Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group STM32_StdPeriph
    ./STM32Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./STM32Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./STM32Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group DFS
    ./RTT/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ./RTT/components/dfs/filesystems/elmfat/: ff.c dfs_elm.c
    ./RTT/components/dfs/filesystems/elmfat/option/: cc936.c
  group SDCard
    ./MySouce/: sdcard.c
  group cpuUsage
    ./MySouce/cpuUsage/: cpuusage.c
  group Keyboard
    ./MySouce/Keyboard/: Keyboard.c
  group LED
    ./MySouce/LED/: LED_my.c beep.c ManualAlarm.c LowVoltageDetecte.c
  group Vocoder
    ./MySouce/Vocoder/: VocoderCommon.c Record_drive.c RecordAPP.c DecoderAPI.c
  group Speex
    ./MySouce/Vocoder/STM32F10x_Speex_Lib/libspeex/: bits.c buffer.c exc_20_32_table.c exc_5_64_table.c exc_5_256_table.c exc_8_128_table.c exc_10_16_table.c exc_10_32_table.c kiss_fft.c filterbank.c gain_table.c gain_table_lbr.c hexc_10_32_table.c hexc_table.c high_lsp_tables.c jitter.c lsp_tables_nb.c kiss_fftr.c lpc.c lsp.c modes_wb.c stereo.c resample.c sb_celp.c smallft.c speex.c speex_callbacks.c speex_header.c vbr.c window.c
    ./MySouce/Vocoder/STM32F10x_Speex_Lib/STM32/libspeex/: vq.c cb_search.c filters.c ltp.c modes.c nb_celp.c quant_lsp.c
  group ATcmd
    ./MySouce/ATcmd/: CDMAHardware.c MC323A.c AT_APP.c unicodetogb2312.c
  group CAN
    ./MySouce/: CAN.c
  group DS1302
    ./MySouce/DS1302/: DS1302.c
  group GNSS
    ./MySouce/: UART1_new .c
    ./MySouce/GNSS/: GNSS_IO.c GNSS.c GNSS_Platform.c GNSS_Splitter.c GNSS_Terminal.c GNSS_APP.c
  group 外接设备
    ./MySouce/PCP/: Adscreen_drive.c AdscreenAPP.c Camera_drvie.c CameraAPP.c GPS_drive.c GPSAPP.c LCD_drive.c LCDAPP.c PCP.c UART2.c UART_Expand.c
  group WatchDog
    ./MySouce/Watchdog/: WatchDog.c
  group Global
    ./MySouce/: Global.c
  group RFID
    ./MySouce/RFID/: FM1702_IO.c ISO14443A.C main.c RFID_APP.c SlRc1702.C SPI_Simulate.c STM32_SPI.c RFID_drive.c
target NoNet (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: 智能终端
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,HAVE_CONFIG_H,BABdebug
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
